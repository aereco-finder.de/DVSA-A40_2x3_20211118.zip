Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DVSA-A40_2x3.IFC
Time: 2021-11-18T08:20:26
Written by: SwIFC
Made in: SolidWorks 2020 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0225C (6)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: 1.0226 (DX51D); Dicke: 1.5; Weight: 0.010; Bezeichnung: Distanzblech; Surface: verzinkt; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0347E (4)
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.407; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0348A
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 0.895; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0374B
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,50; Weight: 0.071; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0560B
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,50; Weight: 0.071; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0628C
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 3.105; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0630A (4)
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 0.065; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0699C
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1; Weight: 1.569; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0700E
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1; Weight: 1.075; Bezeichnung: U-Profil; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0706D
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1; Weight: 1.512; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0707C (2)
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 1.542; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.0717D
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 1,50; Weight: 3.099; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.1222B
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.069; Description: Ventilatortragblech; Benennung: Ventilatortragblech; Surface: verzinkt; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.1369A (3)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: 3.3535 (EN-AW 5754); Dicke: 3; Weight: 0.015; Bezeichnung: Verschlusswinkel SW9; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.1370A (3)
In: Default Storey
SolidWorks Custom Properties - Material: 3.3535 (EN-AW 5754); Dicke: 2; Weight: 0.008; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.1371A (2)
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 2; Weight: 0.022; Bezeichnung: Verschlusswinkel; Bezeichnung2: Durchgangsloch ø 4.9 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.1372A (2)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: 3.3535 (EN-AW 5754); Dicke: 3; Weight: 0.016; Bezeichnung: Verschlusswinkel SW9; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.1494D
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.561; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.1495F
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.555; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.1496D_Tiefgezogen
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 1,50; Weight: 4.875; Bezeichnung: Ventilator-Grundrahmen; Bezeichnung2: DV-A30/A40 VTZ 2/3; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.90100.2668A (2)
In: Default Storey
Material: 1.0226 (DX51D)
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: 0,75; Weight: 1.571; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.95000.0008F
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 0.49; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00200.95000.0008F_Warnhinweis
In: Default Storey
Material: Steel
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 0.49; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_00700.95400.0012A (2)
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
DVSA-A40_00700.95400.0012A | Material: Hochdichte PE-Folie
DVSA-A40_00700.95400.0012A

# IfcBuildingElementProxy: DVSA-A40_10200.00100.0087A_1
In: Default Storey
SolidWorks Custom Properties - Material: Kupfer; Dicke: "Dicke@Blech1"; Weight: 0.013; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10200.00100.0087A_4_DV A50-70
In: Default Storey
SolidWorks Custom Properties - Material: Kupfer; Dicke: "Dicke@Blech1"; Weight: 0.012; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10200.00500.0033B
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 2.00044245; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10200.08000.0026A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech1"; Weight: 0.001; Bezeichnung: Verschlussstopfen VST M20; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10200.08000.0054A (3)
In: Default Storey
Material: PE niedrige/mittlere Dichte
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: PE niedrige/mittlere Dichte; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10200.08000.0059A (5)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: PA Typ 6; Dicke: "Dicke@Blech"; Weight: 0.011; Zuschnittlänge: 1; Zuschnittbreite: 1; Nomenclature: 50.620 PA7001; Part Number: 50.620 PA7001; Source: NOT_KNOWN; Revision: ANY; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10200.08000.0061A (2)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: PA Typ 6; Dicke: "Dicke@Blech"; Weight: 0.002; Zuschnittlänge: 1; Zuschnittbreite: 1; Nomenclature: 50.220 PA7001; Part Number: 50.220 PA7001; Source: NOT_KNOWN; Revision: ANY; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10200.09000.0030A (4)
In: Default Storey
Material: Steel
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: Material <nicht festgelegt>; Dicke: "Dicke@Blech"; Weight: 0.000; Zuschnittlänge: 1; Zuschnittbreite: 1; Beschreibung: Sicherungsscheibe; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00030.0018A_Default (5)
In: Default Storey
SolidWorks Custom Properties - DESIGN: KS Klemmscheibe für Wellen ohne Nut; REFERENCE: KS 5; SUPPLIER: SEEGER-ORBIS; TYPE: CATPART; Material: Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Klemmscheibe M6; Bezeichnung2: DIN 99107-6; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00030.0025A
In: Default Storey
SolidWorks Custom Properties - NN: WN 413; NT: Contact disc; NB: WUERTH 0413008 contact disc M8 Verzinkt; NBSYN: WUERTH $ARTNR. contact disc $NENN. $OBERFLAECHE.; LINA: WUERTH 0413008 contact disc M8 Verzinkt; ROWDESC: M8; ARTNR: 0413008; MATERIAL: Stahl; OBERFLAECHE: Galvanised; ND: M8; D1: 8.20; D2: 16; H: 2.00; B: 1.4; SUPPLIER: WUERTH; ARTICLENO: WUERTH 0413008 contact disc M8 Verzinkt; BOMINFO: WUERTH 0413008 contact disc M8 Verzinkt; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00030.0032A (5)
In: Default Storey
SolidWorks Custom Properties - NN: WN 413; NT: Contact disc; NB: WUERTH 0413008 contact disc M8 Verzinkt; NBSYN: WUERTH $ARTNR. contact disc $NENN. $OBERFLAECHE.; LINA: WUERTH 0413008 contact disc M8 Verzinkt; ROWDESC: M8; ARTNR: 0413008; MATERIAL: 1.0226 (DX51D); OBERFLAECHE: Galvanised; ND: M8; D1: 8.20; D2: 16; H: 2.00; B: 1.4; SUPPLIER: WUERTH; ARTICLENO: WUERTH 0413008 contact disc M8 Verzinkt; BOMINFO: WUERTH 0413008 contact disc M8 Verzinkt; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
2 x DVSA-A40_10400.00030.0032A | Material: 1.0226 (DX51D)
3 x DVSA-A40_10400.00030.0032A

# IfcBuildingElementProxy: DVSA-A40_10400.00055.0172A
In: Default Storey
SolidWorks Custom Properties - NN: DIN 913 (ISO 4026) - A2; NT: Hexagon socket set screws with flat point; NB: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; NBSYN: WUERTH $ARTNR. headless screw DIN 913 $NENN. $GUETE. $OBERFLAECHE.; LINA: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; ROWDESC: M8x40; ARTNR: 02618 40; MATERIAL: Stahl; GUETE: VORDEF; OBERFLAECHE: BLK; D: 8.000; D3: 6.466; P: 1.250; L: 40.000; DP: 5.500; S: 4.000; T: 5.000; SUPPLIER: WUERTH; ARTICLENO: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; BOMINFO: WUERTH 02618 40 headless screw DIN 913 M8x40 VORDEF BLK; CREATOR: CADENAS GmbH; IsFastener: 0; Dicke: -; Weight: 0.015; Bezeichnung: Gewindestift ISO 4026; Bezeichnung2: M8 x 40 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00055.0173A_Default (5)
In: Default Storey
SolidWorks Custom Properties - A: 2.400; ARTICLENO: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; ARTNR: 00465 12; B: 9.600; BOMINFO: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; CREATOR: CADENAS GmbH; D: 5.000; D3: 4.019; DK: 10.000; GUETE: 4.8; K: 3.800; L: 12.000; LINA: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; M: 5.300; MATERIAL: ST; NB: WUERTH 00465 12 oval-head screw DIN 7985 M5x12 4.8 A2K; NBSYN: WUERTH $ARTNR. oval-head screw DIN 7985 $NENN. $GUETE. $OBERFLAECHE.; NN: DIN 7985 (ISO 7045) - 4.8 - zinc-plated (A2K), blue passivated; NT: Cross recessed raised cheese head screws; OBERFLAECHE: A2K; P: 0.800; R: 0.400; RF: 10.000; ROWDESC: M5x12; SUPPLIER: WUERTH; X: 2.000; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
2 x DVSA-A40_10400.00055.0173A_Default | Material: Stahl
3 x DVSA-A40_10400.00055.0173A_Default

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0001A (12)
In: Default Storey
SolidWorks Custom Properties - BEZEICHNUNG: Blindniete 4,8 x 10,0mm; Description: Blindniete 4,8 x 10,0mm; Material: Stahl verzinkt/Stahl verzinkt, blau passiviert; Dicke: -; Weight: 0.000; Bezeichnung2: Klemmbereich: 4.0 - 6.0 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
4 x DVSA-A40_10400.00100.0001A | Material: Stahl verzinkt/Stahl verzinkt, blau passiviert
8 x DVSA-A40_10400.00100.0001A

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0002A (160)
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: Stahl verzinkt/Stahl verzinkt, blau passiviert; Dicke: -; Weight: 0.001; Bezeichnung: Blindniet 3,0 x 6,0; Surface: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
72 x DVSA-A40_10400.00100.0002A | Material: Stahl verzinkt/Stahl verzinkt, blau passiviert
88 x DVSA-A40_10400.00100.0002A

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0016A (4)
In: Default Storey
SolidWorks Custom Properties - Description: RIVKLE®Einnietmutter M5; Material: Stahl; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0019A (46)
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.001; Bezeichnung: Becher-Blindniete 4.0 x 8.0 mm; Bezeichnung2: Klemmbereich: 0.5 - 3.5 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0021A (20)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.001; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
4 x DVSA-A40_10400.00100.0021A | Material: Stahl
16 x DVSA-A40_10400.00100.0021A

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0022A (2)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0029A (5)
In: Default Storey
SolidWorks Custom Properties - Material: Verzinkter Stahl; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name
2 x DVSA-A40_10400.00100.0029A | Material: Verzinkter Stahl
3 x DVSA-A40_10400.00100.0029A

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0041A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.003; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit
Name | Material
2 x DVSA-A40_10400.00100.0041A | Stahl
DVSA-A40_10400.00100.0041A

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0043A
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.011; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0044A (8)
In: Default Storey
SolidWorks Custom Properties - Material: Stahl; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0052A (5)
In: Default Storey
SolidWorks Custom Properties - Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.004; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.00100.0058A (4)
In: Default Storey
Material: Edelstahl A2 / C1
SolidWorks Custom Properties - Description: RIVKLE® Einnietmutter M5; Material: Edelstahl A2 / C1; Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.01000.0002A (3)
In: Default Storey
SolidWorks Custom Properties - Material: Perspex (TM) GS Acrylic Cast Sheet; Dicke: -; Weight: 0.001; Bezeichnung: Sicherungsstopfen; Bezeichnung2: Bohrungen d=8 mm; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.01020.0001A_1 (6)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.015; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.01020.0001A_2 (6)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.013; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10400.01020.0001A_3 (6)
In: Default Storey
SolidWorks Custom Properties - Material: 1.0226 (DX51D); Dicke: -; Weight: 0.002; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10500.00100.0005A_Ventilatortragblech A30-40
In: Default Storey
SolidWorks Custom Properties - Material: Gummi; Dicke: "Dicke@Blech1"; Weight: 0.015; Bezeichnung: Abdichtband; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcBuildingElementProxy: DVSA-A40_10500.00140.0071A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Hauptwarengruppe: Konstruktion; Unterwarengruppe: Dämmstoffzuschnitte; Länge: "Länge@Skizze1"; Breite: "Breite@Skizze1"; Höhe: -; Material: XAC 33; Dicke: 4; Weight: 0.000; Zuschnittlänge: "Länge@Skizze1"; Zuschnittbreite: "Breite@Skizze1"; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Einzelteil; Status: In Arbeit

# IfcElementAssembly: DVSA-A40_00200.90100.0705F_ohne Innenleben
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA-A40_00200.90100.1221G_ohne Innenleben
In: Default Storey
SolidWorks Custom Properties - Description: Deckel mit Sockelaufsatz für VDR.FDSH.DVV2/3; Weight: 4.071; Bezeichnung: Deckel mit Sockelaufsatz; Bezeichnung2: VDR.FDSH.DVV2 / DVV3; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA-A40_00200.90100.2809A
In: Default Storey
SolidWorks Custom Properties - LastSaveDate: 18.11.2021; LastSaveName: wehnes; Material: -; Dicke: -; Weight: 4.875; Bezeichnung: Ventilator-Grundrahmen; Bezeichnung2: DV-A30 / -A40, VTZ 2 / 3; Surface: -; Project: -; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA-A40_02020.20430.0003I_ohne Innenleben
In: Default Storey
SolidWorks Custom Properties - Weight: 15.459; Bezeichnung: Flachdachsockel; Bezeichnung2: Aereco DSFA-A30/40 II / 530072; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA-A40_10200.00500.0040B
In: Default Storey
SolidWorks Custom Properties - Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA-A40_10400.01020.0001A_180° (6)
In: Default Storey
SolidWorks Custom Properties - Material: Material <nicht festgelegt>; Weight: 0.030; Bezeichnung: Scharnier; Bezeichnung2: 50 x 40 x 1.2, gebohrt; Artikelnummer: ---; Erstellt_von: ws; Erstellt_am: 26.10.2021; Dateityp: Baugruppe; Status: In Arbeit

# IfcElementAssembly: DVSA-A40_2x3
In: Default Storey
SolidWorks Custom Properties - Kanalanschluss-Maße mm: 400 x 400; Druckerhöhung zur Auslegung Pa: 130; Maximaler Volumenstrom zur Auslegung (75 %) m3/h: 1.673; Schalldruckpegel in 3 Meter Entfernung zur Auslegung (75 %) - Lp,A dB(A): 51; Schallleistungspegel an der Saugseite zur Auslegung (75 %) - Lw, A dB(A): 50; Maximaler Volumenstrom (100 %) m3/h: 2.230; Schalldruckpegel in 3 Meter Entfernung (100 %) - Lp,A dB(A): 58; Schallleistungspegel an der Saugseite (100 %) - Lw, A dB(A): 55; Schalldruckpegel in 3 Meter Entfernung (50 %) - Lp,A dB(A): 42; Schallleistungspegel an der Saugseite (50 %) - Lw, A dB(A): 44; Digitale Druckregelanzeige: Standard; Einstellbare Druckerhöhung Pa: 5 - 300**; Antriebstechnik: EC-Motor; Reparaturschalter: Standard; Anschlussspannung: 230 V / 50 Hz; Maximaler Nennstrom A: 2,00; Leistungsaufnahme zur Auslegung (75 %) W: 216; SFP zur Auslegung (75 %) W/m³/h: 0,139; Maximale Leistungsaufnahme (Motoranlauf) Watt: 465; Maximale Lufttemperatur °C: 40; Schutzart des Motors IP: 54; Motorschutz: intern; Herausnehmbare Schalldämmungskulisse: Standard; Wärmebrückenfreie Konstruktion (S=50 mm, WLG 035): Standard; Gewicht des Gerätes (Sockel) kg: 75 (51; Material (Gehäuse): verzinktes Stahlblech, Aluminium (Sockel)
PSet_Mass_Property - Mass Measure: 29.6999; Area Measure: 12.5136 m2; Volume Measure: 0.00733732 m3
